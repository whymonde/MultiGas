# Keil uVision project YLB-3330.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MBstmf407 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\out\MBstmf407.bin  .\out\MBstmf407.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\lib\inc;.\lib\src;.\mylib\inc;.\mylib\src;.\sys;.\user;.\out;.\FATFS\src;.\FATFS\exfuns;.\USB_HOST\inc;.\USB_OTG\inc;.\lib\CORE;.\rtthread\3.0.3\components\finsh;.\rtthread\3.0.3\include;.\rtthread\3.0.3\include\libc;.\myScreen\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: main.c define.h
    ./mylib/inc/: flashisp.h
  group mylib
    ./mylib/src/: project.c usart.c printf.c ASCII.c flashisp.c slave.c battery.c button.c file.c MMC_SD.C calculate.c spi.c usb.c process.c AT.c Printer.c SPEAK.c TestPower.c mytimer.c CalculationFormula.c flux.c FM24CL64.c myiic.c APPAT.c POWER.c fan.c LTC2944.c DS18B20.c
    ./user/: stm32f4xx_it.c
  group lib
    ./lib/src/: misc.c stm32f4xx_usart.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group sys
    ./sys/: startup_stm32f40_41xxx.s system_stm32f4xx.c malloc.c sys.c
  group FATS
    ./FATFS/src/: diskio.c ff.c
    ./FATFS/src/option/: cc936.c
    ./FATFS/exfuns/: exfuns.c
  group USB_HOST
    ./USB_HOST/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c usbh_stdreq.c usbh_usr.c
  group USB_OTG
    ./myScreen/scr/: ScreenDrive.c
    ./USB_OTG/src/: usb_bsp.c usb_core.c usb_hcd.c usb_hcd_int.c
  group myScreen
    ./myScreen/scr/: Screen.c Screenlogic.c ScreenDwFunction.c ScreenButton.c ScreenDisCalculate.c
    ./myScreen/inc/: Screen.h ScreenButton.h ScreenDrive.h ScreenDwFunction.h Screenlogic.h
